# Keil uVision project STM32F429.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx
  c include: .\VidaOS\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./USER/: app.c main.c
    ./VidaOS/Inc/: vConfig.h
  group VidaOS
    ./VIDAOS/Src/: vBitmap.c vCPU.c vDelay.c vEvent.c vFlagGruop.c vHooks.c VidaOS.c vList.c vMbox.c vMemBlock.c vMutex.c vSched.c vSem.c vSList.c vTask.c vTimer.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
